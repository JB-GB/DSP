options:
  parameters:
    generate_options: qt_gui
    id: fm_rx_archivo
    output_language: python
    title: FM RX archivo IQ
  states: {bus_structure: 'null'}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: fs de RF; 1.2 Msps es estable en RTL-SDR y divisible a 240k/48k
    value: '1200000'
  states: {}
- name: mpx_rate
  id: variable
  parameters:
    comment: fs tras decimar el canal (samp_rate/5)
    value: samp_rate//5
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fm_dev
  id: variable
  parameters:
    comment: desviacion maxima FM comercial (Hz)
    value: '75000'
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frecuencia central (Hz)
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '89700000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: src
  id: blocks_file_source
  parameters:
    comment: Reproduce una captura .cfile (p. ej. la sintetica de fm_synth.py) sin hardware
    file: synth_fm.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    comment: 'Sin hardware no hay reloj: el throttle impone samp_rate'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channel_lpf
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: 'Aisla el canal FM de 200 kHz: corte 100k, transicion 50k (Kaiser). Decim 5'
    cutoff_freq: '100000'
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_KAISER
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: 'gain = fs/(2*pi*dev): normaliza la desviacion maxima a +-1'
    gain: mpx_rate/(2*math.pi*fm_dev)
  states: {}
- name: deemph
  id: analog_fm_deemph
  parameters:
    comment: De-enfasis 75 us (America)
    samp_rate: mpx_rate
    tau: '75e-6'
  states: {}
- name: audio_lpf
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: Audio 15 kHz; transicion 4 kHz rechaza el piloto de 19 kHz. Decim 5 -> 48 kHz
    cutoff_freq: '15000'
    decim: '5'
    gain: '1'
    samp_rate: mpx_rate
    type: fir_filter_fff
    width: '4000'
    win: window.WIN_KAISER
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: audio_file
  id: blocks_wavfile_sink
  parameters:
    comment: Muestra de audio para results/audio_samples
    file: audio_mono_48k.wav
    samp_rate: audio_rate
    type: float
    format: FORMAT_WAV
    subformat: FORMAT_PCM_16
    bits_per_sample1: FORMAT_PCM_16
  states: {}
- name: mpx_sink
  id: blocks_file_sink
  parameters:
    comment: MPX crudo a 240 kHz (piloto, L-R, RDS) para analisis en Python
    file: mpx_240k.f32
    type: float
  states: {}
- name: rf_spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Espectro de RF antes de demodular
    fc: '0'
    fftsize: '4096'
    name: '"Espectro RF"'
    type: complex
  states: {}
- name: mpx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: mpx_rate
    comment: Aqui se ve el piloto de 19 kHz
    fc: '0'
    fftsize: '4096'
    name: '"Espectro MPX"'
    type: float
  states: {}
- name: audio_spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    comment: Audio demodulado (contenido hasta 15 kHz)
    fc: '0'
    fftsize: '2048'
    name: '"Espectro audio"'
    type: float
  states: {}
- name: rf_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Waterfall de RF
    fc: '0'
    fftsize: '1024'
    name: '"Waterfall RF"'
    type: complex
  states: {}

connections:
- [src, '0', throttle, '0']
- [throttle, '0', channel_lpf, '0']
- [throttle, '0', rf_spectrum, '0']
- [throttle, '0', rf_waterfall, '0']
- [channel_lpf, '0', quad_demod, '0']
- [quad_demod, '0', mpx_sink, '0']
- [quad_demod, '0', mpx_spectrum, '0']
- [quad_demod, '0', deemph, '0']
- [deemph, '0', audio_lpf, '0']
- [audio_lpf, '0', audio_out, '0']
- [audio_lpf, '0', audio_file, '0']
- [audio_lpf, '0', audio_spectrum, '0']

metadata:
  file_format: 1
